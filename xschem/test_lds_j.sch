v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {C} -860 -140 0 1 0.4 0.4 {}
T {C} -130 -150 0 1 0.4 0.4 {}
T {A} -770 -240 0 1 0.4 0.4 {}
T {B} -770 -210 0 1 0.4 0.4 {}
T {G} 690 -270 0 0 0.4 0.4 {}
T {E} -520 100 0 1 0.4 0.4 {}
T {D} -360 90 0 1 0.4 0.4 {}
N 740 -390 740 -330 {
lab=Vbn}
N 670 -390 670 -330 {
lab=Vbn}
N -370 -390 740 -390 {
lab=Vbn}
N -370 -390 -370 -330 {
lab=Vbn}
N -300 -390 -300 -330 {
lab=Vbn}
N 740 -390 790 -390 {
lab=Vbn}
N 600 -330 610 -330 {
lab=#net1}
N 680 -330 680 -260 {
lab=#net1}
N 610 -260 680 -260 {
lab=#net1}
N 610 -330 610 -260 {
lab=#net1}
N -310 -330 -310 -260 {
lab=#net1}
N -310 -260 -230 -260 {
lab=#net1}
N -230 -330 -230 -260 {
lab=#net1}
N -240 -330 -230 -330 {
lab=#net1}
N 640 -370 640 -360 {
lab=Vbp}
N 250 -330 260 -330 {
lab=Vbp}
N 180 -330 190 -330 {
lab=#net1}
N 110 -330 120 -330 {
lab=Vbp}
N 570 -410 570 -360 {
lab=Vbp}
N -200 -410 570 -410 {
lab=Vbp}
N -200 -410 -200 -360 {
lab=Vbp}
N 290 -410 290 -360 {
lab=Vbp}
N 220 -410 220 -360 {
lab=Vbp}
N 150 -410 150 -360 {
lab=Vbp}
N 80 -410 80 -360 {
lab=Vbp}
N 570 -410 790 -410 {
lab=Vbp}
N -340 -410 -200 -410 {
lab=Vbp}
N -340 -410 -340 -360 {
lab=Vbp}
N -270 -410 -270 -360 {
lab=Vbp}
N 710 -410 710 -360 {
lab=Vbp}
N 640 -410 640 -370 {
lab=Vbp}
N 260 -410 260 -330 {
lab=Vbp}
N 110 -410 110 -330 {
lab=Vbp}
N 110 -230 260 -230 {
lab=Vbp}
N 540 -410 540 -330 {
lab=Vbp}
N -170 -410 -170 -330 {
lab=Vbp}
N 260 -230 540 -230 {
lab=Vbp}
N -170 -230 110 -230 {
lab=Vbp}
N 320 -260 610 -260 {
lab=#net1}
N 320 -330 320 -260 {
lab=#net1}
N 190 -260 320 -260 {
lab=#net1}
N 190 -330 190 -260 {
lab=#net1}
N 50 -260 190 -260 {
lab=#net1}
N 50 -330 50 -260 {
lab=#net1}
N -230 -260 50 -260 {
lab=#net1}
N -400 -390 -370 -390 {
lab=Vbn}
N -390 -410 -340 -410 {
lab=Vbp}
N 40 -330 50 -330 {
lab=#net1}
N 320 -330 330 -330 {
lab=#net1}
N 500 -440 500 -360 {
lab=Vcp}
N 430 -440 500 -440 {
lab=Vcp}
N 360 -440 430 -440 {
lab=Vcp}
N 360 -440 360 -360 {
lab=Vcp}
N 20 -440 360 -440 {
lab=Vcp}
N 10 -440 20 -440 {
lab=Vcp}
N 10 -440 10 -360 {
lab=Vcp}
N -60 -440 10 -440 {
lab=Vcp}
N -130 -440 -130 -360 {
lab=Vcp}
N -130 -440 -60 -440 {
lab=Vcp}
N 500 -440 790 -440 {
lab=Vcp}
N -380 -440 -130 -440 {
lab=Vcp}
N 460 -330 470 -330 {
lab=#net1}
N 390 -440 390 -330 {
lab=Vcp}
N -20 -440 -20 -330 {
lab=Vcp}
N -100 -330 -90 -330 {
lab=#net1}
N 770 -390 770 -360 {
lab=Vbn}
N -430 -360 -430 -330 {
lab=Vbn}
N -400 -390 -400 -360 {
lab=Vbn}
N 390 -200 460 -200 {
lab=Vcp}
N -90 -200 -20 -200 {
lab=Vcp}
N -20 -200 390 -200 {
lab=Vcp}
N -300 -90 -300 -80 {
lab=#net2}
N -690 -50 -680 -50 {
lab=Vbn}
N -830 -50 -820 -50 {
lab=Vbn}
N -370 -130 -370 -80 {
lab=#net2}
N -650 -130 -650 -80 {
lab=#net2}
N -720 -130 -720 -80 {
lab=#net2}
N -790 -130 -790 -80 {
lab=#net2}
N -860 -130 -860 -80 {
lab=#net2}
N -370 -130 -150 -130 {
lab=#net2}
N -230 -130 -230 -80 {
lab=#net2}
N -300 -130 -300 -90 {
lab=#net2}
N -900 -50 -890 -50 {
lab=#net2}
N -890 -130 -370 -130 {
lab=#net2}
N -440 -130 -440 -80 {
lab=#net2}
N -170 -110 -140 -110 {
lab=Vbn}
N -260 -110 -260 -50 {
lab=Vbn}
N -260 -110 -170 -110 {
lab=Vbn}
N -270 -50 -260 -50 {
lab=Vbn}
N -410 -50 -400 -50 {
lab=Vbn}
N -410 -110 -410 -50 {
lab=Vbn}
N -410 -110 -260 -110 {
lab=Vbn}
N -550 -50 -540 -50 {
lab=Vbn}
N -480 -110 -480 -50 {
lab=Vbn}
N -480 -110 -410 -110 {
lab=Vbn}
N -610 -110 -610 -50 {
lab=Vbn}
N -610 -110 -480 -110 {
lab=Vbn}
N -680 -110 -610 -110 {
lab=Vbn}
N -680 -110 -680 -50 {
lab=Vbn}
N -820 -110 -820 -50 {
lab=Vbn}
N -330 -50 -330 0 {
lab=Vcn}
N -470 0 -330 0 {
lab=Vcn}
N -470 -50 -470 0 {
lab=Vcn}
N -620 0 -470 0 {
lab=Vcn}
N -620 -50 -620 0 {
lab=Vcn}
N -760 0 -620 0 {
lab=Vcn}
N -760 -50 -760 0 {
lab=Vcn}
N -200 -130 -200 -50 {
lab=#net2}
N -340 -130 -340 -50 {
lab=#net2}
N -820 -110 -680 -110 {
lab=Vbn}
N -750 -130 -750 -50 {
lab=#net2}
N -890 -130 -890 -50 {
lab=#net2}
N -920 -110 -820 -110 {
lab=Vbn}
N -540 -30 -540 120 {
lab=Vbn}
N -760 -230 -170 -230 {
lab=Vbp}
N -750 -200 -90 -200 {
lab=Vcp}
N 500 -50 510 -50 {
lab=Vbp}
N 290 -50 300 -50 {
lab=VN}
N 1020 -110 1050 -110 {
lab=VN}
N 930 -110 930 -50 {
lab=VN}
N 930 -110 1020 -110 {
lab=VN}
N 710 -110 710 -50 {
lab=VN}
N 990 -130 990 -50 {
lab=#net2}
N 250 -110 270 -110 {
lab=VN}
N 960 -80 960 40 {
lab=Ib}
N 330 -80 330 40 {
lab=Ib}
N 330 40 960 40 {
lab=Ib}
N 820 -80 820 40 {
lab=Ib}
N 890 -80 890 40 {
lab=Ib}
N 750 -80 750 40 {
lab=Ib}
N 680 -80 680 40 {
lab=Ib}
N 610 -80 610 40 {
lab=Ib}
N 540 -80 540 40 {
lab=Ib}
N 470 -80 470 40 {
lab=Ib}
N 400 -80 400 40 {
lab=Ib}
N 230 40 330 40 {
lab=Ib}
N 250 -80 250 40 {
lab=Ib}
N -20 40 230 40 {
lab=Ib}
N 780 -130 780 -50 {
lab=#net2}
N 710 -110 930 -110 {
lab=VN}
N 0 -110 250 -110 {
lab=VN}
N -10 -130 210 -130 {
lab=#net2}
N 180 -80 180 40 {
lab=Ib}
N 110 -80 110 40 {
lab=Ib}
N 40 -80 40 40 {
lab=Ib}
N 220 -130 220 -50 {
lab=#net2}
N 10 -130 10 -50 {
lab=#net2}
N 920 -50 930 -50 {
lab=VN}
N 710 -50 720 -50 {
lab=VN}
N 70 -50 80 -50 {
lab=VN}
N 70 -110 70 -50 {
lab=VN}
N 280 -110 280 -50 {
lab=VN}
N 280 -50 290 -50 {
lab=VN}
N 860 -50 860 40 {
lab=Ib}
N 650 -50 650 40 {
lab=Ib}
N 140 -50 140 40 {
lab=Ib}
N 360 -50 360 40 {
lab=Ib}
N 790 -110 790 -50 {
lab=VN}
N 210 -110 210 -50 {
lab=VN}
N 270 -110 710 -110 {
lab=VN}
N -40 -110 0 -110 {
lab=VN}
N 570 -110 570 -50 {
lab=VN}
N 440 -110 440 -50 {
lab=VN}
N 570 -50 580 -50 {
lab=VN}
N 430 -50 440 -50 {
lab=VN}
N 210 -130 990 -130 {
lab=#net2}
N -890 40 -20 40 {
lab=Ib}
N 1020 -80 1050 -80 {
lab=VN}
N 1050 -80 1050 -50 {
lab=VN}
N 1020 -110 1020 -80 {
lab=VN}
N 150 -200 150 -50 {
lab=Vcp}
N 370 -200 370 -50 {
lab=Vcp}
N 460 -200 950 -200 {
lab=Vcp}
N 850 -200 850 -50 {
lab=Vcp}
N 640 -200 640 -50 {
lab=Vcp}
N -540 -50 -540 -30 {
lab=Vbn}
N -390 0 -390 20 {
lab=Vcn}
N -150 -130 -10 -130 {
lab=#net2}
N 500 -230 500 -50 {
lab=Vbp}
N -60 -410 -60 -360 {
lab=Vbp}
N 430 -410 430 -360 {
lab=Vbp}
N 470 -330 470 -260 {
lab=#net1}
N 400 -410 400 -330 {
lab=Vbp}
N -90 -330 -90 -260 {
lab=#net1}
N -30 -410 -30 -330 {
lab=Vbp}
N -160 -440 -160 -330 {
lab=Vcp}
N 530 -440 530 -330 {
lab=Vcp}
N -910 -130 -890 -130 {
lab=#net2}
N -930 -110 -930 -80 {
lab=Vbn}
N -970 -110 -920 -110 {
lab=Vbn}
N 770 230 770 290 {
lab=VN}
N 700 230 700 290 {
lab=VN}
N -340 230 770 230 {
lab=VN}
N -340 230 -340 290 {
lab=VN}
N -270 230 -270 290 {
lab=VN}
N 770 230 820 230 {
lab=VN}
N 630 290 640 290 {
lab=#net3}
N 710 290 710 360 {
lab=#net3}
N 640 360 710 360 {
lab=#net3}
N 640 290 640 360 {
lab=#net3}
N -280 290 -280 360 {
lab=#net3}
N -280 360 -200 360 {
lab=#net3}
N -200 290 -200 360 {
lab=#net3}
N -210 290 -200 290 {
lab=#net3}
N 670 250 670 260 {
lab=Vbn}
N 280 290 290 290 {
lab=Vbn}
N 210 290 220 290 {
lab=#net3}
N 140 290 150 290 {
lab=Vbn}
N 600 210 600 260 {
lab=Vbn}
N -170 210 600 210 {
lab=Vbn}
N -170 210 -170 260 {
lab=Vbn}
N 320 210 320 260 {
lab=Vbn}
N 250 210 250 260 {
lab=Vbn}
N 180 210 180 260 {
lab=Vbn}
N 110 210 110 260 {
lab=Vbn}
N 600 210 820 210 {
lab=Vbn}
N -310 210 -170 210 {
lab=Vbn}
N -310 210 -310 260 {
lab=Vbn}
N -240 210 -240 260 {
lab=Vbn}
N 740 210 740 260 {
lab=Vbn}
N 670 210 670 250 {
lab=Vbn}
N 290 210 290 290 {
lab=Vbn}
N 140 210 140 290 {
lab=Vbn}
N 570 210 570 290 {
lab=Vbn}
N -140 210 -140 290 {
lab=Vbn}
N 350 360 640 360 {
lab=#net3}
N 350 290 350 360 {
lab=#net3}
N 220 360 350 360 {
lab=#net3}
N 220 290 220 360 {
lab=#net3}
N 80 360 220 360 {
lab=#net3}
N 80 290 80 360 {
lab=#net3}
N -200 360 80 360 {
lab=#net3}
N -370 230 -340 230 {
lab=VN}
N -360 210 -310 210 {
lab=Vbn}
N 70 290 80 290 {
lab=#net3}
N 350 290 360 290 {
lab=#net3}
N 530 180 530 260 {
lab=Vcn}
N 460 180 530 180 {
lab=Vcn}
N 390 180 460 180 {
lab=Vcn}
N 390 180 390 260 {
lab=Vcn}
N 50 180 390 180 {
lab=Vcn}
N 40 180 50 180 {
lab=Vcn}
N 40 180 40 260 {
lab=Vcn}
N -30 180 40 180 {
lab=Vcn}
N -100 180 -100 260 {
lab=Vcn}
N -100 180 -30 180 {
lab=Vcn}
N 530 180 820 180 {
lab=Vcn}
N -350 180 -100 180 {
lab=Vcn}
N 490 290 500 290 {
lab=#net3}
N 420 180 420 290 {
lab=Vcn}
N 10 180 10 290 {
lab=Vcn}
N -70 290 -60 290 {
lab=#net3}
N 830 260 830 290 {
lab=VN}
N 800 260 830 260 {
lab=VN}
N 800 230 800 260 {
lab=VN}
N -400 260 -400 290 {
lab=VN}
N -400 260 -370 260 {
lab=VN}
N -370 230 -370 260 {
lab=VN}
N -400 230 -370 230 {
lab=VN}
N -30 210 -30 260 {
lab=Vbn}
N 460 210 460 260 {
lab=Vbn}
N 500 290 500 360 {
lab=#net3}
N 430 210 430 290 {
lab=Vbn}
N -60 290 -60 360 {
lab=#net3}
N 0 210 0 290 {
lab=Vbn}
N -130 180 -130 290 {
lab=Vcn}
N 560 180 560 290 {
lab=Vcn}
N -540 210 -360 210 {
lab=Vbn}
N -540 120 -540 210 {
lab=Vbn}
N -390 20 -390 180 {
lab=Vcn}
N -390 180 -350 180 {
lab=Vcn}
N -580 -130 -580 -80 {
lab=#net2}
N -510 -130 -510 -80 {
lab=#net2}
N 810 -390 810 -240 {
lab=Vbp}
N 810 -400 810 -390 {
lab=Vbp}
N -430 -390 -430 -360 {
lab=Vbn}
N -430 -390 -400 -390 {
lab=Vbn}
N -470 -390 -400 -390 {
lab=Vbn}
N 790 -390 800 -390 {
lab=Vbn}
N 800 -390 800 -330 {
lab=Vbn}
N 790 -440 900 -440 {
lab=Vcp}
N 880 -440 880 -200 {
lab=Vcp}
N 790 -410 820 -410 {
lab=Vbp}
N 540 -230 810 -230 {
lab=Vbp}
N 810 -240 810 -230 {
lab=Vbp}
N 810 -410 810 -400 {
lab=Vbp}
N -960 -110 -960 -50 {
lab=Vbn}
N -970 -370 -970 -110 {
lab=Vbn}
N -970 -370 -450 -370 {
lab=Vbn}
N -450 -390 -450 -370 {
lab=Vbn}
N -40 -110 -40 230 {
lab=VN}
C {madvlsi/pmos3.sym} 770 -330 3 1 {name=MD2
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 710 -330 3 1 {name=M7d
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 640 -330 3 1 {name=M7c
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 570 -330 3 1 {name=M9h
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 290 -330 3 1 {name=M9f
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 220 -330 3 1 {name=M9e
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 150 -330 3 1 {name=M9d
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -60 -330 3 1 {name=M9b
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -130 -330 3 1 {name=M8a
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -200 -330 3 1 {name=M9a
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -270 -330 3 1 {name=M7b
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -340 -330 3 1 {name=M7a
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -400 -330 3 1 {name=MD1
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -230 -50 3 1 {name=M3d
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -300 -50 3 1 {name=M2d
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -370 -50 3 1 {name=M3c
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -440 -50 3 1 {name=M2c
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -510 -50 3 1 {name=M1b
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -580 -50 3 1 {name=M1a
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -650 -50 3 1 {name=M2b
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -720 -50 3 1 {name=M3b
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -790 -50 3 1 {name=M2a
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -860 -50 3 1 {name=M3a
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 960 -50 3 1 {name=M10d
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 890 -50 3 1 {name=M13d
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 820 -50 3 1 {name=M11d
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 750 -50 3 1 {name=M10c
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 680 -50 3 1 {name=M13c
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 610 -50 3 1 {name=M11c
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 540 -50 3 1 {name=M12b
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 470 -50 3 1 {name=M12a
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 400 -50 3 1 {name=M11b
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 330 -50 3 1 {name=M13b
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 250 -50 3 1 {name=M10b
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 180 -50 3 1 {name=M11a
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 110 -50 3 1 {name=M13a
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 40 -50 3 1 {name=M10a
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/iopin.sym} -890 40 0 1 {name=p4 lab=Ib}
C {madvlsi/nmos3.sym} 1020 -50 3 1 {name=MD4
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 80 -330 3 1 {name=M9c
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 360 -330 3 1 {name=M8c
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 10 -330 3 1 {name=M8b
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 430 -330 3 1 {name=M9g
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 500 -330 3 1 {name=M8d
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -930 -50 3 1 {name=MD3
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -310 290 1 0 {name=M6a
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -240 290 1 0 {name=M6b
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -170 290 1 0 {name=M5a
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -100 290 1 0 {name=M4a
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -30 290 1 0 {name=M5b
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 110 290 1 0 {name=M5c
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 180 290 1 0 {name=M5d
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 40 290 1 0 {name=M4b
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 250 290 1 0 {name=M5e
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 320 290 1 0 {name=M5f
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 460 290 1 0 {name=M5g
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 390 290 1 0 {name=M4c
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 530 290 1 0 {name=M4d
L=8
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 600 290 1 0 {name=M5h
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 670 290 1 0 {name=M6c
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 740 290 1 0 {name=M6d
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 800 290 1 0 {name=MD6
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -370 290 1 0 {name=MD5
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/iopin.sym} 820 180 2 1 {name=p8 lab=Vcn}
C {devices/iopin.sym} 820 210 2 1 {name=p1 lab=Vbn}
C {devices/iopin.sym} 900 -440 2 1 {name=p7 lab=Vcp}
C {devices/iopin.sym} 820 -410 2 1 {name=p6 lab=Vbp}
C {devices/iopin.sym} 820 230 2 1 {name=p2 lab=VN}
C {devices/iopin.sym} -470 -390 2 0 {name=p3 lab=VP}
