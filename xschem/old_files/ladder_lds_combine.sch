v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/madvlsi/Documents/DAC-VLSI/xschem/ladder_lds_no_inverter.sym} -30 -60 0 0 {name=x1}
