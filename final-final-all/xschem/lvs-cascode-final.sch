v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {C} 220 280 0 1 0.4 0.4 {}
T {C} 910 270 0 1 0.4 0.4 {}
T {A} 270 180 0 1 0.4 0.4 {}
T {B} 270 210 0 1 0.4 0.4 {}
T {G} 1730 150 0 0 0.4 0.4 {}
T {E} 730 500 0 1 0.4 0.4 {}
T {D} 680 510 0 1 0.4 0.4 {}
N 1710 30 1710 90 {
lab=VDD}
N 670 30 1780 30 {
lab=VDD}
N 740 30 740 90 {
lab=VDD}
N 1780 30 1830 30 {
lab=VDD}
N 1640 90 1650 90 {
lab=#net1}
N 1720 90 1720 160 {
lab=#net1}
N 1650 160 1720 160 {
lab=#net1}
N 1650 90 1650 160 {
lab=#net1}
N 730 90 730 160 {
lab=#net1}
N 730 160 810 160 {
lab=#net1}
N 810 90 810 160 {
lab=#net1}
N 800 90 810 90 {
lab=#net1}
N 1680 50 1680 60 {
lab=#net2}
N 1290 90 1300 90 {
lab=#net2}
N 1220 90 1230 90 {
lab=#net1}
N 1150 90 1160 90 {
lab=#net2}
N 1610 10 1610 60 {
lab=#net2}
N 840 10 1610 10 {
lab=#net2}
N 840 10 840 60 {
lab=#net2}
N 1330 10 1330 60 {
lab=#net2}
N 1260 10 1260 60 {
lab=#net2}
N 1190 10 1190 60 {
lab=#net2}
N 1120 10 1120 60 {
lab=#net2}
N 1610 10 1830 10 {
lab=#net2}
N 700 10 840 10 {
lab=#net2}
N 700 10 700 60 {
lab=#net2}
N 770 10 770 60 {
lab=#net2}
N 1750 10 1750 60 {
lab=#net2}
N 1680 10 1680 50 {
lab=#net2}
N 1300 10 1300 90 {
lab=#net2}
N 1150 10 1150 90 {
lab=#net2}
N 1150 190 1300 190 {
lab=#net2}
N 1580 10 1580 90 {
lab=#net2}
N 870 10 870 90 {
lab=#net2}
N 1300 190 1580 190 {
lab=#net2}
N 870 190 1150 190 {
lab=#net2}
N 1360 160 1650 160 {
lab=#net1}
N 1360 90 1360 160 {
lab=#net1}
N 1230 160 1360 160 {
lab=#net1}
N 1230 90 1230 160 {
lab=#net1}
N 1090 160 1230 160 {
lab=#net1}
N 1090 90 1090 160 {
lab=#net1}
N 810 160 1090 160 {
lab=#net1}
N 640 30 670 30 {
lab=VDD}
N 650 10 700 10 {
lab=#net2}
N 1080 90 1090 90 {
lab=#net1}
N 1360 90 1370 90 {
lab=#net1}
N 1540 -20 1540 60 {
lab=Vcp}
N 1470 -20 1540 -20 {
lab=Vcp}
N 1400 -20 1470 -20 {
lab=Vcp}
N 1400 -20 1400 60 {
lab=Vcp}
N 1060 -20 1400 -20 {
lab=Vcp}
N 1050 -20 1060 -20 {
lab=Vcp}
N 1050 -20 1050 60 {
lab=Vcp}
N 980 -20 1050 -20 {
lab=Vcp}
N 910 -20 910 60 {
lab=Vcp}
N 910 -20 980 -20 {
lab=Vcp}
N 1540 -20 1830 -20 {
lab=Vcp}
N 660 -20 910 -20 {
lab=Vcp}
N 1500 90 1510 90 {
lab=#net1}
N 1430 -20 1430 90 {
lab=Vcp}
N 1020 -20 1020 90 {
lab=Vcp}
N 940 90 950 90 {
lab=#net1}
N 1810 30 1810 60 {
lab=VDD}
N 610 60 610 90 {
lab=VDD}
N 640 30 640 60 {
lab=VDD}
N 1430 220 1500 220 {
lab=Vcp}
N 950 220 1020 220 {
lab=Vcp}
N 1020 220 1430 220 {
lab=Vcp}
N 920 330 920 340 {
lab=Vbp}
N 610 290 610 340 {
lab=Vbp}
N 530 290 530 340 {
lab=Vbp}
N 670 290 890 290 {
lab=Vbp}
N 920 290 920 330 {
lab=Vbp}
N 460 370 470 370 {
lab=VDD}
N 150 290 670 290 {
lab=Vbp}
N 820 290 820 340 {
lab=Vbp}
N 870 310 900 310 {
lab=VDD}
N 960 310 960 370 {
lab=VDD}
N 780 310 870 310 {
lab=VDD}
N 950 370 960 370 {
lab=VDD}
N 850 310 850 370 {
lab=VDD}
N 630 310 780 310 {
lab=VDD}
N 710 370 720 370 {
lab=#net3}
N 780 310 780 370 {
lab=VDD}
N 780 310 850 310 {
lab=VDD}
N 650 310 650 370 {
lab=VDD}
N 650 310 780 310 {
lab=VDD}
N 580 310 580 370 {
lab=VDD}
N 890 370 890 420 {
lab=Vcn}
N 790 370 790 420 {
lab=Vcn}
N 640 420 790 420 {
lab=Vcn}
N 640 370 640 420 {
lab=Vcn}
N 280 420 420 420 {
lab=Vcn}
N 560 370 560 420 {
lab=Vcn}
N 220 310 360 310 {
lab=VDD}
N 120 310 220 310 {
lab=VDD}
N 280 190 870 190 {
lab=#net2}
N 290 220 950 220 {
lab=Vcp}
N 1540 370 1550 370 {
lab=#net2}
N 1830 310 1860 310 {
lab=GND}
N 1970 310 2060 310 {
lab=GND}
N 1290 310 1310 310 {
lab=GND}
N 1370 460 2000 460 {
lab=Vbn}
N 1730 340 1730 460 {
lab=Vbn}
N 1650 340 1650 460 {
lab=Vbn}
N 1580 340 1580 460 {
lab=Vbn}
N 1510 340 1510 460 {
lab=Vbn}
N 1440 340 1440 460 {
lab=Vbn}
N 1270 460 1370 460 {
lab=Vbn}
N 1020 460 1270 460 {
lab=Vbn}
N 1750 310 1970 310 {
lab=GND}
N 1040 310 1290 310 {
lab=GND}
N 1030 290 1250 290 {
lab=Vbp}
N 1360 340 1360 460 {
lab=Vbn}
N 1700 310 1700 370 {
lab=GND}
N 1390 310 1390 370 {
lab=GND}
N 1310 310 1750 310 {
lab=GND}
N 1000 310 1040 310 {
lab=GND}
N 1610 310 1610 370 {
lab=GND}
N 1480 310 1480 370 {
lab=GND}
N 1610 370 1620 370 {
lab=GND}
N 1470 370 1480 370 {
lab=GND}
N 1250 290 2030 290 {
lab=Vbp}
N 150 460 1020 460 {
lab=Vbn}
N 1830 340 1860 340 {
lab=GND}
N 1860 340 1860 370 {
lab=GND}
N 1830 310 1830 340 {
lab=GND}
N 1330 220 1330 370 {
lab=Vcp}
N 1410 220 1410 370 {
lab=Vcp}
N 1500 220 1990 220 {
lab=Vcp}
N 1760 220 1760 370 {
lab=Vcp}
N 1680 220 1680 370 {
lab=Vcp}
N 720 370 720 390 {
lab=#net3}
N 650 420 650 440 {
lab=Vcn}
N 890 290 1030 290 {
lab=Vbp}
N 1540 190 1540 370 {
lab=#net2}
N 980 10 980 60 {
lab=#net2}
N 1470 10 1470 60 {
lab=#net2}
N 1510 90 1510 160 {
lab=#net1}
N 1440 10 1440 90 {
lab=#net2}
N 950 90 950 160 {
lab=#net1}
N 1010 10 1010 90 {
lab=#net2}
N 880 -20 880 90 {
lab=Vcp}
N 1570 -20 1570 90 {
lab=Vcp}
N 430 310 430 340 {
lab=VDD}
N 1810 650 1810 710 {
lab=GND}
N 1740 650 1740 710 {
lab=GND}
N 700 650 1810 650 {
lab=GND}
N 700 650 700 710 {
lab=GND}
N 770 650 770 710 {
lab=GND}
N 1810 650 1860 650 {
lab=GND}
N 1670 710 1680 710 {
lab=#net4}
N 1750 710 1750 780 {
lab=#net4}
N 1680 780 1750 780 {
lab=#net4}
N 1680 710 1680 780 {
lab=#net4}
N 760 710 760 780 {
lab=#net4}
N 760 780 840 780 {
lab=#net4}
N 840 710 840 780 {
lab=#net4}
N 830 710 840 710 {
lab=#net4}
N 1710 670 1710 680 {
lab=#net3}
N 1320 710 1330 710 {
lab=#net3}
N 1250 710 1260 710 {
lab=#net4}
N 1180 710 1190 710 {
lab=#net3}
N 1640 630 1640 680 {
lab=#net3}
N 870 630 1640 630 {
lab=#net3}
N 870 630 870 680 {
lab=#net3}
N 1360 630 1360 680 {
lab=#net3}
N 1290 630 1290 680 {
lab=#net3}
N 1220 630 1220 680 {
lab=#net3}
N 1150 630 1150 680 {
lab=#net3}
N 1640 630 1860 630 {
lab=#net3}
N 730 630 870 630 {
lab=#net3}
N 730 630 730 680 {
lab=#net3}
N 800 630 800 680 {
lab=#net3}
N 1780 630 1780 680 {
lab=#net3}
N 1710 630 1710 670 {
lab=#net3}
N 1330 630 1330 710 {
lab=#net3}
N 1180 630 1180 710 {
lab=#net3}
N 1610 630 1610 710 {
lab=#net3}
N 900 630 900 710 {
lab=#net3}
N 1390 780 1680 780 {
lab=#net4}
N 1390 710 1390 780 {
lab=#net4}
N 1260 780 1390 780 {
lab=#net4}
N 1260 710 1260 780 {
lab=#net4}
N 1120 780 1260 780 {
lab=#net4}
N 1120 710 1120 780 {
lab=#net4}
N 840 780 1120 780 {
lab=#net4}
N 670 650 700 650 {
lab=GND}
N 680 630 730 630 {
lab=#net3}
N 1110 710 1120 710 {
lab=#net4}
N 1390 710 1400 710 {
lab=#net4}
N 1570 600 1570 680 {
lab=Vcn}
N 1500 600 1570 600 {
lab=Vcn}
N 1430 600 1500 600 {
lab=Vcn}
N 1430 600 1430 680 {
lab=Vcn}
N 1090 600 1430 600 {
lab=Vcn}
N 1080 600 1090 600 {
lab=Vcn}
N 1080 600 1080 680 {
lab=Vcn}
N 1010 600 1080 600 {
lab=Vcn}
N 940 600 940 680 {
lab=Vcn}
N 940 600 1010 600 {
lab=Vcn}
N 1570 600 1860 600 {
lab=Vcn}
N 690 600 940 600 {
lab=Vcn}
N 1530 710 1540 710 {
lab=#net4}
N 1460 600 1460 710 {
lab=Vcn}
N 1050 600 1050 710 {
lab=Vcn}
N 970 710 980 710 {
lab=#net4}
N 1870 680 1870 710 {
lab=GND}
N 1840 680 1870 680 {
lab=GND}
N 1840 650 1840 680 {
lab=GND}
N 640 680 640 710 {
lab=GND}
N 640 680 670 680 {
lab=GND}
N 670 650 670 680 {
lab=GND}
N 640 650 670 650 {
lab=GND}
N 1010 630 1010 680 {
lab=#net3}
N 1500 630 1500 680 {
lab=#net3}
N 1540 710 1540 780 {
lab=#net4}
N 1470 630 1470 710 {
lab=#net3}
N 980 710 980 780 {
lab=#net4}
N 1040 630 1040 710 {
lab=#net3}
N 910 600 910 710 {
lab=Vcn}
N 1600 600 1600 710 {
lab=Vcn}
N 500 630 680 630 {
lab=#net3}
N 650 440 650 600 {
lab=Vcn}
N 650 600 690 600 {
lab=Vcn}
N 680 290 680 340 {
lab=Vbp}
N 750 290 750 340 {
lab=Vbp}
N 1850 30 1850 180 {
lab=#net2}
N 1850 20 1850 30 {
lab=#net2}
N 610 30 610 60 {
lab=VDD}
N 610 30 640 30 {
lab=VDD}
N 570 30 640 30 {
lab=VDD}
N 1830 30 1840 30 {
lab=VDD}
N 1840 30 1840 90 {
lab=VDD}
N 1830 -20 1940 -20 {
lab=Vcp}
N 1920 -20 1920 220 {
lab=Vcp}
N 1830 10 1860 10 {
lab=#net2}
N 1580 190 1850 190 {
lab=#net2}
N 1850 180 1850 190 {
lab=#net2}
N 1850 10 1850 20 {
lab=#net2}
N 400 310 400 370 {
lab=VDD}
N 70 50 70 310 {
lab=VDD}
N 70 50 590 50 {
lab=VDD}
N 590 30 590 50 {
lab=VDD}
N 1000 310 1000 650 {
lab=GND}
N 1760 370 1800 370 {
lab=Vcp}
N 900 310 960 310 {
lab=VDD}
N 580 310 630 310 {
lab=VDD}
N 720 390 720 630 {
lab=#net3}
N 420 420 640 420 {
lab=Vcn}
N 360 310 580 310 {
lab=VDD}
N 70 310 120 310 {
lab=VDD}
N 790 420 890 420 {
lab=Vcn}
N 470 370 500 370 {
lab=VDD}
N 480 310 480 370 {
lab=VDD}
N 1780 30 1780 90 {
lab=VDD}
N 670 30 670 90 {
lab=VDD}
C {madvlsi/pmos3.sym} 1810 90 3 1 {name=MD2
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1750 90 3 1 {name=M7d
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1680 90 3 1 {name=M7c
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1610 90 3 1 {name=M9h
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1330 90 3 1 {name=M9f
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1260 90 3 1 {name=M9e
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1190 90 3 1 {name=M9d
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 980 90 3 1 {name=M9b
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 910 90 3 1 {name=M8a
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 840 90 3 1 {name=M9a
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 770 90 3 1 {name=M7b
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 700 90 3 1 {name=M7a
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 640 90 3 1 {name=MD1
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 920 370 3 1 {name=M2d
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 820 370 3 1 {name=M2c
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 750 370 3 1 {name=M1b
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 680 370 3 1 {name=M1a
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 610 370 3 1 {name=M2b
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 530 370 3 1 {name=M2a
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1730 370 3 1 {name=M11d
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1650 370 3 1 {name=M11c
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1580 370 3 1 {name=M12b
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1510 370 3 1 {name=M12a
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1440 370 3 1 {name=M11b
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1360 370 3 1 {name=M11a
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1830 370 3 1 {name=MD4
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1120 90 3 1 {name=M9c
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1400 90 3 1 {name=M8c
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1050 90 3 1 {name=M8b
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1470 90 3 1 {name=M9g
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1540 90 3 1 {name=M8d
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 430 370 3 1 {name=MD3
L=8
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 730 710 1 0 {name=M6a
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 800 710 1 0 {name=M6b
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 870 710 1 0 {name=M5a
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 940 710 1 0 {name=M4a
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1010 710 1 0 {name=M5b
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1150 710 1 0 {name=M5c
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1220 710 1 0 {name=M5d
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1080 710 1 0 {name=M4b
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1290 710 1 0 {name=M5e
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1360 710 1 0 {name=M5f
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1500 710 1 0 {name=M5g
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1430 710 1 0 {name=M4c
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1570 710 1 0 {name=M4d
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1640 710 1 0 {name=M5h
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1710 710 1 0 {name=M6c
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1780 710 1 0 {name=M6d
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1840 710 1 0 {name=MD6
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 670 710 1 0 {name=MD5
L=8
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 150 460 0 0 {name=p4 lab=Vbn}
C {devices/ipin.sym} 150 290 0 0 {name=p5 lab=Vbp}
C {devices/opin.sym} 1940 -20 0 0 {name=p1 lab=Vcp}
C {devices/opin.sym} 1860 600 0 0 {name=p6 lab=Vcn}
C {madvlsi/vdd.sym} 570 30 0 0 {name=l1 lab=VDD}
C {madvlsi/gnd.sym} 1860 650 0 0 {name=l2 lab=GND}
